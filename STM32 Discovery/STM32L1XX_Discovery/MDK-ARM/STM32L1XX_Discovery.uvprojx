# Keil uVision project STM32L1XX_Discovery.uvprojx, settings and files
target STM32L1XX_Discovery Configuration (ARM-ADS)
  device: STM32L100RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L100xC
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32L1xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: main.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l100xc.s
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_comp.c stm32l1xx_hal_gpio.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_uart.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_crc.c stm32l1xx_hal_cortex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_tim.c stm32l1xx_hal_dma.c stm32l1xx_hal_i2c.c stm32l1xx_hal_rcc.c stm32l1xx_hal_dac.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_spi.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_adc.c stm32l1xx_hal.c stm32l1xx_hal_rtc.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
software components: CMSIS:CORE 4.1.0
